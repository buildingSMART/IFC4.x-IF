Properties of the parts of a building model (IFC4X3)

# File
Description: ViewDefinition [Ifc4X3NotAssigned]
File name: ACCA - RFI - Signalling.ifc
Time: 2022-05-16T12:38:48
Written by: ACCA_IFC.dll Version 500
Made in: ACCA usBIM.infra

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 m

# IfcElementAssembly: Home Signal (protection) (7)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
2a - Home Signal - SAN FELICE A CANCELLO | LO5800
3a - Home Signal - SANTA MARIA A VICO | LO5801
4a - Home Signal - ARPAIA | LO5802
5a - Home Signal - CERVINARA | LO5804
6a - Home Signal - SAN MARTINO | LO5805
7a - Home Signal - TUFARA | LO5806
8a - Home Signal - BENEVENTO APPIA | LO5908

# IfcElementAssembly: Home Signal (protection) 180 (8)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1b - Home Signal - CANCELLO | LO0848
2b - Home Signal - SAN FELICE A CANCELLO | LO5800
3b - Home Signal - SANTA MARIA A VICO | LO5801
4b - Home Signal - ARPAIA | LO5802
5b - Home Signal - CERVINARA | LO5804
6b - Home Signal - SAN MARTINO | LO5805
7b - Home Signal - TUFARA | LO5806
8b - Home Signal - BENEVENTO APPIA | LO5908

# IfcElementAssembly: Outer Signal (warning) (8)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
2a - Outer Signal - SAN FELICE A CANCELLO | LO5800
3a - Outer Signal - SANTA MARIA A VICO | LO5801
4a - Outer Signal - ARPAIA | LO5802
5a - Outer Signal - CERVINARA | LO5804
6a - Outer Signal - SAN MARTINO | LO5805
7a - Outer Signal - TUFARA | LO5806
8a - Outer Signal - BENEVENTO APPIA | LO5908
9a - Outer Signal - BENEVENTO | LO0626

# IfcElementAssembly: Outer Signal (warning) 180 (7)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1b - Outer Signal - CANCELLO | LO0848
2b - Outer Signal - SAN FELICE A CANCELLO | LO5800
3b - Outer Signal - SANTA MARIA A VICO | LO5801
4b - Outer Signal - ARPAIA | LO5802
5b - Outer Signal - CERVINARA | LO5804
6b - Outer Signal - SAN MARTINO | LO5805
7b - Outer Signal - TUFARA | LO5806

# IfcElementAssembly: Routing Signal (starting) (8)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1a - Routing Signal - CANCELLO | LO0848
2a - Routing Signal - SAN FELICE A CANCELLO | LO5800
3a - Routing Signal - SANTA MARIA A VICO | LO5801
4a - Routing Signal - ARPAIA | LO5802
5a - Routing Signal - CERVINARA | LO5804
6a - Routing Signal - SAN MARTINO | LO5805
7a - Routing Signal - TUFARA | LO5806
8a - Routing Signal - BENEVENTO APPIA | LO5908

# IfcElementAssembly: Routing Signal (starting) 180 (7)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
2b - Routing Signal - SAN FELICE A CANCELLO | LO5800
3b - Routing Signal - SANTA MARIA A VICO | LO5801
4b - Routing Signal - ARPAIA | LO5802
5b - Routing Signal - CERVINARA | LO5804
6b - Routing Signal - SAN MARTINO | LO5805
7b - Routing Signal - TUFARA | LO5806
8b - Routing Signal - BENEVENTO APPIA | LO5908

# IfcFooting: Segnale_3_vele_1_footing (45)
Type - PredefinedType: PAD_FOOTING
Name | In
3 x Fondazione | LO0848
6 x Fondazione | LO5800
6 x Fondazione | LO5801
6 x Fondazione | LO5802
6 x Fondazione | LO5804
6 x Fondazione | LO5805
6 x Fondazione | LO5806
5 x Fondazione | LO5908
Fondazione | LO0626

# IfcMember: Segnale_3_vele_2_pole (23)
Type - PredefinedType: POST
Name | In
Palo | LO0848
3 x Palo | LO5800
3 x Palo | LO5801
3 x Palo | LO5802
3 x Palo | LO5804
3 x Palo | LO5805
3 x Palo | LO5806
3 x Palo | LO5908
Palo | LO0626

# IfcMember: Segnale_3_vele_2_pole_180 (22)
Type - PredefinedType: POST
Name | In
2 x Palo | LO0848
3 x Palo | LO5800
3 x Palo | LO5801
3 x Palo | LO5802
3 x Palo | LO5804
3 x Palo | LO5805
3 x Palo | LO5806
2 x Palo | LO5908

# IfcRailway (22)
Name | Description
Linea Cancello-Benevento
LO0848 | CANCELLO
TR7800 | Tratta Cancello - San Felice a Cancello
LO5800 | SAN FELICE A CANCELLO
TR7801 | Tratta San Felice a Cancello - Santa Maria a Vico
LO5801 | SANTA MARIA A VICO
TR7802 | Tratta Santa Maria a Vico - Arpaia
LO5802 | ARPAIA
TR7803 | Tratta Arpaia - Rotondi-Paolis
LO5803 | ROTONDI - PAOLISI
TR7804 | Tratta Rotondi-Paolis - Cervinara
LO5804 | CERVINARA
TR7805 | Tratta Cervinara - San Martino
LO5805 | SAN MARTINO
TR7806 | Tratta San Martino - Tufara
LO5806 | TUFARA
TR7807 | Tratta Tufara - Benevento Rione Libertà
LO5807 | BENEVENTO RIONE LIBERTA'
TR7808 | Tratta Benevento Rione Libertà - Benevento Appia
LO5908 | BENEVENTO APPIA
TR7809 | Tratta Benevento Appia - Benevento
LO0626 | BENEVENTO

# IfcRailwayPart (21)
UsageType: LONGITUDINAL; PredefinedType: TRACKSTRUCTUREPART

# IfcSignal: Segnale_3_vele_4_velagialla (8)
Type - PredefinedType: VISUAL
Name | In
Vela Gialla | LO5800
Vela Gialla | LO5801
Vela Gialla | LO5802
Vela Gialla | LO5804
Vela Gialla | LO5805
Vela Gialla | LO5806
Vela Gialla | LO5908
Vela Gialla | LO0626

# IfcSignal: Segnale_3_vele_4_velagialla_180 (7)
Type - PredefinedType: VISUAL
Name | In
Vela Gialla | LO0848
Vela Gialla | LO5800
Vela Gialla | LO5801
Vela Gialla | LO5802
Vela Gialla | LO5804
Vela Gialla | LO5805
Vela Gialla | LO5806

# IfcSignal: Segnale_3_vele_4_velarossa (23)
Type - PredefinedType: VISUAL
Name | In
2 x Vela Rossa | LO0848
3 x Vela Rossa | LO5800
3 x Vela Rossa | LO5801
3 x Vela Rossa | LO5802
3 x Vela Rossa | LO5804
3 x Vela Rossa | LO5805
3 x Vela Rossa | LO5806
3 x Vela Rossa | LO5908

# IfcSignal: Segnale_3_vele_4_velarossa_180 (22)
Type - PredefinedType: VISUAL
Name | In
Vela Rossa | LO0848
3 x Vela Rossa | LO5800
3 x Vela Rossa | LO5801
3 x Vela Rossa | LO5802
3 x Vela Rossa | LO5804
3 x Vela Rossa | LO5805
3 x Vela Rossa | LO5806
3 x Vela Rossa | LO5908

# IfcSignal: Segnale_3_vele_4_velaverde (38)
Type - PredefinedType: VISUAL
Name | In
Vela Verde | LO0848
5 x Vela Verde | LO5800
5 x Vela Verde | LO5801
5 x Vela Verde | LO5802
5 x Vela Verde | LO5804
5 x Vela Verde | LO5805
5 x Vela Verde | LO5806
5 x Vela Verde | LO5908
2 x Vela Verde | LO0626

# IfcSignal: Segnale_3_vele_4_velaverde_180 (37)
Type - PredefinedType: VISUAL
Name | In
4 x Vela Verde | LO0848
5 x Vela Verde | LO5800
5 x Vela Verde | LO5801
5 x Vela Verde | LO5802
5 x Vela Verde | LO5804
5 x Vela Verde | LO5805
5 x Vela Verde | LO5806
3 x Vela Verde | LO5908
