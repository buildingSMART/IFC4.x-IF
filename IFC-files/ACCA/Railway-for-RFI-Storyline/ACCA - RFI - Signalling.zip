Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedReferenceView]
File name: ACCA - RFI - Signalling.ifc
Time: 2024-06-25T10:49:36
Written by: ACCA_IFC.dll Version 500
Made in: ACCA - usBIM

# IfcElementAssembly: Home Signal (protection) (15)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1b - Home Signal - CANCELLO | LO0848
2a - Home Signal - SAN FELICE A CANCELLO | LO5800
2b - Home Signal - SAN FELICE A CANCELLO | LO5800
3a - Home Signal - SANTA MARIA A VICO | LO5801
3b - Home Signal - SANTA MARIA A VICO | LO5801
4a - Home Signal - ARPAIA | LO5802
4b - Home Signal - ARPAIA | LO5802
5a - Home Signal - CERVINARA | LO5804
5b - Home Signal - CERVINARA | LO5804
6a - Home Signal - SAN MARTINO | LO5805
6b - Home Signal - SAN MARTINO | LO5805
7a - Home Signal - TUFARA | LO5806
7b - Home Signal - TUFARA | LO5806
8a - Home Signal - BENEVENTO APPIA | LO5908
8b - Home Signal - BENEVENTO APPIA | LO5908

# IfcElementAssembly: Outer Signal (warning) (15)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1b - Outer Signal - CANCELLO | LO0848
2a - Outer Signal - SAN FELICE A CANCELLO | LO5800
2b - Outer Signal - SAN FELICE A CANCELLO | LO5800
3a - Outer Signal - SANTA MARIA A VICO | LO5801
3b - Outer Signal - SANTA MARIA A VICO | LO5801
4a - Outer Signal - ARPAIA | LO5802
4b - Outer Signal - ARPAIA | LO5802
5a - Outer Signal - CERVINARA | LO5804
5b - Outer Signal - CERVINARA | LO5804
6a - Outer Signal - SAN MARTINO | LO5805
6b - Outer Signal - SAN MARTINO | LO5805
7a - Outer Signal - TUFARA | LO5806
7b - Outer Signal - TUFARA | LO5806
8a - Outer Signal - BENEVENTO APPIA | LO5908
9a - Outer Signal - BENEVENTO | LO0626

# IfcElementAssembly: Routing Signal (starting) (15)
Type - PredefinedType: SIGNALASSEMBLY
Name | In
1a - Routing Signal - CANCELLO | LO0848
2a - Routing Signal - SAN FELICE A CANCELLO | LO5800
2b - Routing Signal - SAN FELICE A CANCELLO | LO5800
3a - Routing Signal - SANTA MARIA A VICO | LO5801
3b - Routing Signal - SANTA MARIA A VICO | LO5801
4a - Routing Signal - ARPAIA | LO5802
4b - Routing Signal - ARPAIA | LO5802
5a - Routing Signal - CERVINARA | LO5804
5b - Routing Signal - CERVINARA | LO5804
6a - Routing Signal - SAN MARTINO | LO5805
6b - Routing Signal - SAN MARTINO | LO5805
7a - Routing Signal - TUFARA | LO5806
7b - Routing Signal - TUFARA | LO5806
8a - Routing Signal - BENEVENTO APPIA | LO5908
8b - Routing Signal - BENEVENTO APPIA | LO5908

# IfcFooting: Segnale_3_vele_1_footing (45)
Type - PredefinedType: PAD_FOOTING
Name | In
3 x Fondazione | LO0848
6 x Fondazione | LO5800
6 x Fondazione | LO5801
6 x Fondazione | LO5802
6 x Fondazione | LO5804
6 x Fondazione | LO5805
6 x Fondazione | LO5806
5 x Fondazione | LO5908
Fondazione | LO0626

# IfcMember: Segnale_3_vele_2_pole (45)
Type - PredefinedType: POST
Name | In
3 x Palo | LO0848
6 x Palo | LO5800
6 x Palo | LO5801
6 x Palo | LO5802
6 x Palo | LO5804
6 x Palo | LO5805
6 x Palo | LO5806
5 x Palo | LO5908
Palo | LO0626

# IfcRailway (22)
Name | Description
Linea Cancello-Benevento
LO0848 | CANCELLO
TR7800 | Tratta Cancello - San Felice a Cancello
LO5800 | SAN FELICE A CANCELLO
TR7801 | Tratta San Felice a Cancello - Santa Maria a Vico
LO5801 | SANTA MARIA A VICO
TR7802 | Tratta Santa Maria a Vico - Arpaia
LO5802 | ARPAIA
TR7803 | Tratta Arpaia - Rotondi-Paolis
LO5803 | ROTONDI - PAOLISI
TR7804 | Tratta Rotondi-Paolis - Cervinara
LO5804 | CERVINARA
TR7805 | Tratta Cervinara - San Martino
LO5805 | SAN MARTINO
TR7806 | Tratta San Martino - Tufara
LO5806 | TUFARA
TR7807 | Tratta Tufara - Benevento Rione Libertà
LO5807 | BENEVENTO RIONE LIBERTA'
TR7808 | Tratta Benevento Rione Libertà - Benevento Appia
LO5908 | BENEVENTO APPIA
TR7809 | Tratta Benevento Appia - Benevento
LO0626 | BENEVENTO

# IfcRailwayPart (21)
UsageType: LONGITUDINAL; PredefinedType: TRACKPART

# IfcSignal: Segnale_3_vele_4_velagialla (15)
Type - PredefinedType: VISUAL
Name | In
Vela Gialla | LO0848
2 x Vela Gialla | LO5800
2 x Vela Gialla | LO5801
2 x Vela Gialla | LO5802
2 x Vela Gialla | LO5804
2 x Vela Gialla | LO5805
2 x Vela Gialla | LO5806
Vela Gialla | LO5908
Vela Gialla | LO0626

# IfcSignal: Segnale_3_vele_4_velarossa (45)
Type - PredefinedType: VISUAL
Name | In
3 x Vela Rossa | LO0848
6 x Vela Rossa | LO5800
6 x Vela Rossa | LO5801
6 x Vela Rossa | LO5802
6 x Vela Rossa | LO5804
6 x Vela Rossa | LO5805
6 x Vela Rossa | LO5806
6 x Vela Rossa | LO5908

# IfcSignal: Segnale_3_vele_4_velaverde (75)
Type - PredefinedType: VISUAL
Name | In
5 x Vela Verde | LO0848
10 x Vela Verde | LO5800
10 x Vela Verde | LO5801
10 x Vela Verde | LO5802
10 x Vela Verde | LO5804
10 x Vela Verde | LO5805
10 x Vela Verde | LO5806
8 x Vela Verde | LO5908
2 x Vela Verde | LO0626
