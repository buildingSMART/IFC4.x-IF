Properties of the parts of a building model (IFC4X3_ADD2), part 3 of 3

# IfcTrackElement: Traversina Monoblocco (2990)
Name
Sleeper TR7804 #_2972
Sleeper TR7804 #_2973
Sleeper TR7804 #_2974
Sleeper TR7804 #_2975
Sleeper TR7804 #_2976
Sleeper TR7804 #_2977
Sleeper TR7804 #_2978
Sleeper TR7804 #_2979
Sleeper TR7804 #_2980
Sleeper TR7804 #_2981
Sleeper TR7804 #_2982
Sleeper TR7804 #_2983
Sleeper TR7804 #_2984
Sleeper TR7804 #_2985
Sleeper TR7804 #_2986
Sleeper TR7804 #_2987
Sleeper TR7804 #_2988
Sleeper TR7804 #_2989
Sleeper TR7804 #_2990
