Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedReferenceView]
File name: ACCA - RFI - Telecom.ifc
Time: 2024-06-25T10:50:16
Written by: ACCA_IFC.dll Version 500
Made in: ACCA - usBIM

# IfcBuildingElementProxy: Cable Junction (10)
In: TR7800
Type - Material: Junction Material
Name | SweepStart (m) | SweepEnd (m)
Junction 500 | 499.65 | 500.35
Junction 1000 | 999.65 | 1000.35
Junction 1500 | 1499.65 | 1500.35
Junction 2000 | 1999.65 | 2000.35
Junction 2500 | 2499.65 | 2500.35
Junction 3000 | 2999.65 | 3000.35
Junction 3500 | 3499.65 | 3500.35
Junction 4000 | 3999.65 | 4000.35
Junction 4500 | 4499.65 | 4500.35
Junction 5000 | 4999.65 | 5000.35

# IfcBuildingElementProxy: Copper Cable (8)
Type - Material: Copper
Name | In | SweepStart (m) | SweepEnd (m)
Cable | LO0848 | 0 | 50
Cable | LO0848 | 50 | 100
Cable | LO0848 | 100 | 150
Cable | LO0848 | 150 | 200
Cable | LO0848 | 200 | 250
Cable | LO0848 | 250 | 300
Cable | LO0848 | 300 | 318.3
Cable | TR7800 | 318.3 | 5430.78

# IfcBuildingElementProxy: v317 (8)
Type - Material: Concrete
Name | In | SweepStart (m) | SweepEnd (m)
Duct | LO0848 | 0 | 50
Duct | LO0848 | 50 | 100
Duct | LO0848 | 100 | 150
Duct | LO0848 | 150 | 200
Duct | LO0848 | 200 | 250
Duct | LO0848 | 250 | 300
Duct | LO0848 | 300 | 318.3
Duct | TR7800 | 318.3 | 5430.78

# IfcBuildingElementProxy: v317_top (8)
Type - Material: Concrete
Name | In | SweepStart (m) | SweepEnd (m)
Duct (top) | LO0848 | 0 | 50
Duct (top) | LO0848 | 50 | 100
Duct (top) | LO0848 | 100 | 150
Duct (top) | LO0848 | 150 | 200
Duct (top) | LO0848 | 200 | 250
Duct (top) | LO0848 | 250 | 300
Duct (top) | LO0848 | 300 | 318.3
Duct (top) | TR7800 | 318.3 | 5430.78

# IfcRailway (22)
Name | Description
Linea Cancello-Benevento
LO0848 | CANCELLO
TR7800 | Tratta Cancello - San Felice a Cancello
LO5800 | SAN FELICE A CANCELLO
TR7801 | Tratta San Felice a Cancello - Santa Maria a Vico
LO5801 | SANTA MARIA A VICO
TR7802 | Tratta Santa Maria a Vico - Arpaia
LO5802 | ARPAIA
TR7803 | Tratta Arpaia - Rotondi-Paolis
LO5803 | ROTONDI - PAOLISI
TR7804 | Tratta Rotondi-Paolis - Cervinara
LO5804 | CERVINARA
TR7805 | Tratta Cervinara - San Martino
LO5805 | SAN MARTINO
TR7806 | Tratta San Martino - Tufara
LO5806 | TUFARA
TR7807 | Tratta Tufara - Benevento Rione Libertà
LO5807 | BENEVENTO RIONE LIBERTA'
TR7808 | Tratta Benevento Rione Libertà - Benevento Appia
LO5908 | BENEVENTO APPIA
TR7809 | Tratta Benevento Appia - Benevento
LO0626 | BENEVENTO

# IfcRailwayPart (21)
UsageType: LONGITUDINAL; PredefinedType: TRACKPART
